# Keil uVision project nrf52840_bootloader_usb_debug.uvprojx, settings and files
target nrf52840_xxaa_debug (5060960::V5.06 update 7 (build 960)::.\1)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa_debug +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET DEBUG_NRF FLOAT_ABI_HARD MBR_PRESENT NRF52840_XXAA NRF_DFU_DEBUG_VERSION NRF_DFU_SETTINGS_VERSION=2 SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION __HEAP_SIZE=0
  c misc: --reduce_paths
  c include: ..\config;..\nRF5_SDK_17.1.0\components\boards;..\nRF5_SDK_17.1.0\components\drivers_nrf\nrf_soc_nosd;..\nRF5_SDK_17.1.0\components\libraries\atomic;..\nRF5_SDK_17.1.0\components\libraries\atomic_fifo;..\nRF5_SDK_17.1.0\components\libraries\balloc;..\nRF5_SDK_17.1.0\components\libraries\bootloader;..\nRF5_SDK_17.1.0\components\libraries\bootloader\dfu;..\nRF5_SDK_17.1.0\components\libraries\bootloader\serial_dfu;..\nRF5_SDK_17.1.0\components\libraries\crc32;..\nRF5_SDK_17.1.0\components\libraries\crypto;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\cc310;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\cc310_bl;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\cifra;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\mbedtls;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\micro_ecc;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\nrf_hw;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\nrf_sw;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\oberon;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\optiga;..\nRF5_SDK_17.1.0\components\libraries\delay;..\nRF5_SDK_17.1.0\components\libraries\experimental_section_vars;..\nRF5_SDK_17.1.0\components\libraries\fstorage;..\nRF5_SDK_17.1.0\components\libraries\log;..\nRF5_SDK_17.1.0\components\libraries\log\src;..\nRF5_SDK_17.1.0\components\libraries\mem_manager;..\nRF5_SDK_17.1.0\components\libraries\memobj;..\nRF5_SDK_17.1.0\components\libraries\mutex;..\nRF5_SDK_17.1.0\components\libraries\queue;..\nRF5_SDK_17.1.0\components\libraries\ringbuf;..\nRF5_SDK_17.1.0\components\libraries\scheduler;..\nRF5_SDK_17.1.0\components\libraries\slip;..\nRF5_SDK_17.1.0\components\libraries\stack_info;..\nRF5_SDK_17.1.0\components\libraries\strerror;..\nRF5_SDK_17.1.0\components\libraries\usbd;..\nRF5_SDK_17.1.0\components\libraries\usbd\class\cdc;..\nRF5_SDK_17.1.0\components\libraries\usbd\class\cdc\acm;..\nRF5_SDK_17.1.0\components\libraries\util;..\nRF5_SDK_17.1.0\components\softdevice\mbr\headers;..\nRF5_SDK_17.1.0\external\fprintf;..\nRF5_SDK_17.1.0\external\nano-pb;..\nRF5_SDK_17.1.0\external\nrf_cc310\include;..\nRF5_SDK_17.1.0\external\nrf_cc310_bl\include;..\nRF5_SDK_17.1.0\external\nrf_oberon;..\nRF5_SDK_17.1.0\external\nrf_oberon\include;..\nRF5_SDK_17.1.0\external\segger_rtt;..\nRF5_SDK_17.1.0\external\utf_converter;..\nRF5_SDK_17.1.0\integration\nrfx;..\nRF5_SDK_17.1.0\integration\nrfx\legacy;..\nRF5_SDK_17.1.0\modules\nrfx;..\nRF5_SDK_17.1.0\modules\nrfx\drivers\include;..\nRF5_SDK_17.1.0\modules\nrfx\hal;..\user
  asm define: as above
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DCONFIG_GPIO_AS_PINRESET,-DDEBUG_NRF,-DFLOAT_ABI_HARD,-DMBR_PRESENT,-DNRF52840_XXAA,-DNRF_DFU_DEBUG_VERSION,-DNRF_DFU_SETTINGS_VERSION=2,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-D__HEAP_SIZE=0
  asm include: ..\..\config;..\nRF5_SDK_17.1.0\components\boards;..\nRF5_SDK_17.1.0\components\drivers_nrf\nrf_soc_nosd;..\nRF5_SDK_17.1.0\components\libraries\atomic;..\nRF5_SDK_17.1.0\components\libraries\atomic_fifo;..\nRF5_SDK_17.1.0\components\libraries\balloc;..\nRF5_SDK_17.1.0\components\libraries\bootloader;..\nRF5_SDK_17.1.0\components\libraries\bootloader\dfu;..\nRF5_SDK_17.1.0\components\libraries\bootloader\serial_dfu;..\nRF5_SDK_17.1.0\components\libraries\crc32;..\nRF5_SDK_17.1.0\components\libraries\crypto;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\cc310;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\cc310_bl;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\cifra;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\mbedtls;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\micro_ecc;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\nrf_hw;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\nrf_sw;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\oberon;..\nRF5_SDK_17.1.0\components\libraries\crypto\backend\optiga;..\nRF5_SDK_17.1.0\components\libraries\delay;..\nRF5_SDK_17.1.0\components\libraries\experimental_section_vars;..\nRF5_SDK_17.1.0\components\libraries\fstorage;..\nRF5_SDK_17.1.0\components\libraries\log;..\nRF5_SDK_17.1.0\components\libraries\log\src;..\nRF5_SDK_17.1.0\components\libraries\mem_manager;..\nRF5_SDK_17.1.0\components\libraries\memobj;..\nRF5_SDK_17.1.0\components\libraries\mutex;..\nRF5_SDK_17.1.0\components\libraries\queue;..\nRF5_SDK_17.1.0\components\libraries\ringbuf;..\nRF5_SDK_17.1.0\components\libraries\scheduler;..\nRF5_SDK_17.1.0\components\libraries\slip;..\nRF5_SDK_17.1.0\components\libraries\stack_info;..\nRF5_SDK_17.1.0\components\libraries\strerror;..\nRF5_SDK_17.1.0\components\libraries\usbd;..\nRF5_SDK_17.1.0\components\libraries\usbd\class\cdc;..\nRF5_SDK_17.1.0\components\libraries\usbd\class\cdc\acm;..\nRF5_SDK_17.1.0\components\libraries\util;..\nRF5_SDK_17.1.0\components\softdevice\mbr\headers;..\..;..\nRF5_SDK_17.1.0\external\fprintf;..\nRF5_SDK_17.1.0\external\nano-pb;..\nRF5_SDK_17.1.0\external\nrf_cc310\include;..\nRF5_SDK_17.1.0\external\nrf_cc310_bl\include;..\nRF5_SDK_17.1.0\external\nrf_oberon;..\nRF5_SDK_17.1.0\external\nrf_oberon\include;..\nRF5_SDK_17.1.0\external\segger_rtt;..\nRF5_SDK_17.1.0\external\utf_converter;..\nRF5_SDK_17.1.0\integration\nrfx;..\nRF5_SDK_17.1.0\integration\nrfx\legacy;..\nRF5_SDK_17.1.0\modules\nrfx;..\nRF5_SDK_17.1.0\modules\nrfx\drivers\include;..\nRF5_SDK_17.1.0\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0xec000 size 0x12000
  memory RVCT9: RAM 0x20000008 size 0x3fff8
  link misc: --diag_suppress 6330
  group Application
    ../user/: main.c
    ../config/: sdk_config.h dfu_public_key.c
  group Board Definition
    ../nRF5_SDK_17.1.0/components/boards/: boards.c
  group UTF8/UTF16 converter
    ../nRF5_SDK_17.1.0/external/utf_converter/: utf.c
  group nRF_Bootloader
    ../nRF5_SDK_17.1.0/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_final.c nrf_bootloader_dfu_timers.c nrf_bootloader_fw_activation.c nrf_bootloader_info.c nrf_bootloader_wdt.c
  group nRF_Crypto
    ../nRF5_SDK_17.1.0/components/libraries/crypto/: nrf_crypto_ecc.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_shared.c
  group nRF_Crypto backend CC310_BL
    ../nRF5_SDK_17.1.0/components/libraries/crypto/backend/cc310_bl/: cc310_bl_backend_ecc.c cc310_bl_backend_ecdsa.c cc310_bl_backend_hash.c cc310_bl_backend_init.c cc310_bl_backend_shared.c
  group nRF_Crypto backend Oberon
    ../nRF5_SDK_17.1.0/components/libraries/crypto/backend/oberon/: oberon_backend_chacha_poly_aead.c oberon_backend_ecc.c oberon_backend_ecdh.c oberon_backend_ecdsa.c oberon_backend_eddsa.c oberon_backend_hash.c oberon_backend_hmac.c
  group nRF_DFU
    ../nRF5_SDK_17.1.0/components/libraries/bootloader/dfu/: dfu-cc.pb.c nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_req_handler.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c nrf_dfu_validation.c nrf_dfu_ver_validation.c
  group nRF_Drivers
    ../nRF5_SDK_17.1.0/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_uart.c
    ../nRF5_SDK_17.1.0/components/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../nRF5_SDK_17.1.0/modules/nrfx/hal/: nrf_nvmc.c
    ../nRF5_SDK_17.1.0/modules/nrfx/soc/: nrfx_atomic.c
    ../nRF5_SDK_17.1.0/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_power.c nrfx_systick.c nrfx_uart.c nrfx_uarte.c nrfx_usbd.c
    ../nRF5_SDK_17.1.0/modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../nRF5_SDK_17.1.0/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../nRF5_SDK_17.1.0/components/libraries/scheduler/: app_scheduler.c
    ../nRF5_SDK_17.1.0/components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../nRF5_SDK_17.1.0/components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
    ../nRF5_SDK_17.1.0/components/libraries/crc32/: crc32.c
    ../nRF5_SDK_17.1.0/components/libraries/mem_manager/: mem_manager.c
    ../nRF5_SDK_17.1.0/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../nRF5_SDK_17.1.0/components/libraries/atomic/: nrf_atomic.c
    ../nRF5_SDK_17.1.0/components/libraries/balloc/: nrf_balloc.c
    ../nRF5_SDK_17.1.0/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../nRF5_SDK_17.1.0/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../nRF5_SDK_17.1.0/components/libraries/memobj/: nrf_memobj.c
    ../nRF5_SDK_17.1.0/components/libraries/queue/: nrf_queue.c
    ../nRF5_SDK_17.1.0/components/libraries/ringbuf/: nrf_ringbuf.c
    ../nRF5_SDK_17.1.0/components/libraries/strerror/: nrf_strerror.c
    ../nRF5_SDK_17.1.0/components/libraries/slip/: slip.c
  group nRF_Log
    ../nRF5_SDK_17.1.0/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Oberon_Crypto
    ../nRF5_SDK_17.1.0/external/nrf_oberon/lib/cortex-m4/hard-float/short-wchar/: oberon_3.0.8.lib
  group nRF_Segger_RTT
    ../nRF5_SDK_17.1.0/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_Serial_DFU
    ../nRF5_SDK_17.1.0/components/libraries/bootloader/serial_dfu/: nrf_dfu_serial.c
  group nRF_USB_DFU
    ../nRF5_SDK_17.1.0/components/libraries/bootloader/serial_dfu/: nrf_dfu_serial_usb.c
  group nano-pb
    ../nRF5_SDK_17.1.0/external/nano-pb/: pb_common.c pb_decode.c
  group nrf_cc310_bl
    ../nRF5_SDK_17.1.0/external/nrf_cc310_bl/lib/cortex-m4/hard-float/short-wchar/: nrf_cc310_bl_0.9.13.lib
target flash_mbr (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.44.1
  cpu: as above
  output: mbr_nrf52_2.4.1_mbr.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: as above
  c misc: --reduce_paths
  c include: as above
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0xec000 size 0x12000
  memory RVCT9: RAM 0x20000008 size 0x3fff8
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.6.0, Device:Startup 8.44.1
